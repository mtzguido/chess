## scripts/defconfig
```kconfig
cat <<EOF >.config
CONFIG_ZTABLE_SIZE=2048
CONFIG_TTABLE_SIZE=2097152

CONFIG_DEBUG=n
CONFIG_RELEASE=y
CONFIG_PROFOPT=n
CONFIG_FIXOPTS=n
CONFIG_FLIPBIT=n
EOF
```
